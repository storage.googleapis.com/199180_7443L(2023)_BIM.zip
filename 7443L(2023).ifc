Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:03:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:03:37 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\5df2a9b4-071e-42b3-aabb-4c32c966670e\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:03:36 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:03:37 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:03:37 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7443L Bath and shower faucet, 160cc, 7443L(2023):7443L Bath and shower faucet, 160cc:80808
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 159 mm; NominalHeight: 72 mm; NominalWidth: 290 mm
Type - General - Author: BIMStone; BIMObjectName: 7443L(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic bath and shower faucet; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 9.52; CO2 Emissions (A4): 0.34; CO2 Emissions (B7): 1688; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.68; CO2 Emissions (D): -6.04; EAN Number: 6414150104480; EN Standard: EN 1111; Noise Class: II (ISO 3822) Oras lab.; RSK Number: 8245066; Sales Package dimensions (LxWxH): 294 x 164 x 83; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7443L; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/189401_Oras_EPD_Shower_faucet_2022_06_29.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/188596_7443L_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7443L
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7443L; 3D View: https://static.oras.com/AR/7443L; Catalog Drawing URL: http://static.oras.com/catdrw/7443L; Description: Thermostatic bath and shower faucet; Dimension Drawing URL: http://static.oras.com/dimdrw/7443L; FDV Document URL: http://www.oras.com/datasheet/7443L/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7443L; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7443L; Interactive AR View URL: https://static.oras.com/AR/7443L; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7443L; Model: 7443L Bath and shower faucet, 160cc; Name_en: 7443L Bath and shower faucet, 160cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7443L; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7443L; Product URL: http://static.oras.com/7443L; Spare-Part Information URL: http://static.oras.com/sp/7443L; Technical DataSheet URL: http://www.oras.com/datasheet/7443L/en; Type Name: 7443L Bath and shower faucet, 160cc; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: M26x1.5; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.00565035 m3/s; Flow Rate At 300kPa: 0.0116538 m3/s; Installation Type: Wall mounted; Installation Width: cc160 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s);Thermostatic cartridge for automatic temperature control; Pressure Loss With Flow 02ls: 230000 Pa; Pressure Loss With Flow 03ls: 300000 Pa; Shower Parts: Eco flow control; Spout Projection: 138 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Thermostatic safety stop at 38°C;Temperature fixable; Temperature Adjustments: Safety stop against scalding at 38°C;Temperature preset fixable; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: Temperature and volume control, diverter, EcoFlow control; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7443L(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7443L; Name: 7443L Bath and shower faucet, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: 290x159x72 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0804407 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 160 mm; OutletAngle: 90 deg; Volume: 0.00333229 m3
Identity Data - Mark: 34
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7443L(2023): 7443L Bath and shower faucet, 160cc; Family and Type: 7443L(2023): 7443L Bath and shower faucet, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7443L(2023): 7443L Bath and shower faucet, 160cc; Type Id: 7443L(2023): 7443L Bath and shower faucet, 160cc; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
